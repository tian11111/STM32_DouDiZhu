# Keil uVision project P01_lvgl_stm32.uvprojx, settings and files
target P01_lvgl_stm32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: P01_lvgl_stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=1,188,177,111,1295 --multibyte_chars
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../lvgl;./interface;./ui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lvgl/demos/benchmark/assets
    ../lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
  group lvgl/demos/benchmark
    ../lvgl/demos/benchmark/: lv_demo_benchmark.c
  group lvgl/demos/gltf
    ../lvgl/demos/gltf/: lv_demo_gltf.c
  group lvgl/demos/keypad_encoder
    ../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group lvgl/demos
    ../lvgl/demos/: lv_demos.c
  group lvgl/demos/music/assets
    ../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group lvgl/demos/music
    ../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group lvgl/demos/render/assets
    ../lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_argb8888_premultiplied.c img_render_lvgl_logo_i1.c img_render_lvgl_logo_l8.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb565a8.c img_render_lvgl_logo_rgb565_swapped.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
  group lvgl/demos/render
    ../lvgl/demos/render/: lv_demo_render.c
  group lvgl/demos/stress
    ../lvgl/demos/stress/: lv_demo_stress.c
  group lvgl/demos/vector_graphic/assets
    ../lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
  group lvgl/demos/vector_graphic
    ../lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
  group lvgl/demos/widgets/assets
    ../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group lvgl/demos/widgets
    ../lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
  group lvgl/porting
    ../lvgl/porting/: lv_port_indev.c lv_port_lcd_stm32.c
  group lvgl/src/core
    ../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group lvgl/src/debugging/monkey
    ../lvgl/src/debugging/monkey/: lv_monkey.c
  group lvgl/src/debugging/sysmon
    ../lvgl/src/debugging/sysmon/: lv_sysmon.c
  group lvgl/src/debugging/test
    ../lvgl/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
  group lvgl/src/debugging/vg_lite_tvg
    ../lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
  group lvgl/src/display
    ../lvgl/src/display/: lv_display.c
  group lvgl/src/draw/convert/helium
    ../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
  group lvgl/src/draw/convert
    ../lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group lvgl/src/draw/convert/neon
    ../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
  group lvgl/src/draw/dma2d
    ../lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
  group lvgl/src/draw/espressif/ppa
    ../lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
  group lvgl/src/draw/eve
    ../lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
  group lvgl/src/draw
    ../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group lvgl/src/draw/nanovg
    ../lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
  group lvgl/src/draw/nema_gfx
    ../lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
  group lvgl/src/draw/nxp/g2d
    ../lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
  group lvgl/src/draw/nxp/pxp
    ../lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
  group lvgl/src/draw/opengles
    ../lvgl/src/draw/opengles/: lv_draw_opengles.c
  group lvgl/src/draw/renesas/dave2d
    ../lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
  group lvgl/src/draw/sdl
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c
  group lvgl/src/draw/snapshot
    ../lvgl/src/draw/snapshot/: lv_snapshot.c
  group lvgl/src/draw/sw/blend
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group lvgl/src/draw/sw/blend/neon
    ../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
  group lvgl/src/draw/sw/blend/riscv_v
    ../lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
  group lvgl/src/draw/sw
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group lvgl/src/draw/vg_lite
    ../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group lvgl/src/drivers/display/drm
    ../lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
  group lvgl/src/drivers/display/fb
    ../lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
  group lvgl/src/drivers/display/ft81x
    ../lvgl/src/drivers/display/ft81x/: lv_ft81x.c
  group lvgl/src/drivers/display/ili9341
    ../lvgl/src/drivers/display/ili9341/: lv_ili9341.c
  group lvgl/src/drivers/display/lcd
    ../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group lvgl/src/drivers/display/lovyan_gfx
    ../lvgl/src/drivers/display/lovyan_gfx/: lv_lovyan_gfx.cpp
  group lvgl/src/drivers/display/nv3007
    ../lvgl/src/drivers/display/nv3007/: lv_nv3007.c
  group lvgl/src/drivers/display/nxp_elcdif
    ../lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
  group lvgl/src/drivers/display/renesas_glcdc
    ../lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
  group lvgl/src/drivers/display/st7735
    ../lvgl/src/drivers/display/st7735/: lv_st7735.c
  group lvgl/src/drivers/display/st7789
    ../lvgl/src/drivers/display/st7789/: lv_st7789.c
  group lvgl/src/drivers/display/st7796
    ../lvgl/src/drivers/display/st7796/: lv_st7796.c
  group lvgl/src/drivers/display/st_ltdc
    ../lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
  group lvgl/src/drivers/display/tft_espi
    ../lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp
  group lvgl/src/drivers/draw/eve
    ../lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
  group lvgl/src/drivers/evdev
    ../lvgl/src/drivers/evdev/: lv_evdev.c
  group lvgl/src/drivers/libinput
    ../lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
  group lvgl/src/drivers/nuttx
    ../lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
  group lvgl/src/drivers/opengles/assets
    ../lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
  group lvgl/src/drivers/opengles/glad/src
    ../lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
  group lvgl/src/drivers/opengles
    ../lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
  group lvgl/src/drivers/opengles/opengl_shader
    ../lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
  group lvgl/src/drivers/qnx
    ../lvgl/src/drivers/qnx/: lv_qnx.c
  group lvgl/src/drivers/sdl
    ../lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
  group lvgl/src/drivers/uefi
    ../lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
  group lvgl/src/drivers/wayland
    ../lvgl/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
  group lvgl/src/drivers/windows
    ../lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
  group lvgl/src/drivers/x11
    ../lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group lvgl/src/font/binfont_loader
    ../lvgl/src/font/binfont_loader/: lv_binfont_loader.c
  group lvgl/src/font/fmt_txt
    ../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
  group lvgl/src/font/font_manager
    ../lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
  group lvgl/src/font/imgfont
    ../lvgl/src/font/imgfont/: lv_imgfont.c
  group lvgl/src/font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/src/indev
    ../lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/src/layouts/flex
    ../lvgl/src/layouts/flex/: lv_flex.c
  group lvgl/src/layouts/grid
    ../lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/src/layouts
    ../lvgl/src/layouts/: lv_layout.c
  group lvgl/src/libs/barcode
    ../lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group lvgl/src/libs/bin_decoder
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group lvgl/src/libs/bmp
    ../lvgl/src/libs/bmp/: lv_bmp.c
  group lvgl/src/libs/ffmpeg
    ../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group lvgl/src/libs/freetype
    ../lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group lvgl/src/libs/frogfs/src
    ../lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
  group lvgl/src/libs/fsdrv
    ../lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
  group lvgl/src/libs/FT800-FT813
    ../lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
  group lvgl/src/libs/gif
    ../lvgl/src/libs/gif/: gif.c
  group lvgl/src/libs/gltf/gltf_data
    ../lvgl/src/libs/gltf/gltf_data/: lv_gltf_data.cpp lv_gltf_data_animations.cpp lv_gltf_data_cache.cpp lv_gltf_data_injest.cpp lv_gltf_data_mesh.cpp lv_gltf_data_primitive.cpp lv_gltf_data_shader.cpp lv_gltf_data_skin.cpp lv_gltf_data_texture.cpp lv_gltf_model_node.cpp lv_gltf_uniform_locations.cpp
  group lvgl/src/libs/gltf/gltf_environment
    ../lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
  group lvgl/src/libs/gltf/gltf_view/assets
    ../lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
  group lvgl/src/libs/gltf/gltf_view
    ../lvgl/src/libs/gltf/gltf_view/: lv_gltf_view.cpp lv_gltf_view_render.cpp lv_gltf_view_shader.cpp
  group lvgl/src/libs/gltf/math
    ../lvgl/src/libs/gltf/math/: lv_3dmath.c lv_gltf_math.cpp
  group lvgl/src/libs/gstreamer
    ../lvgl/src/libs/gstreamer/: lv_gstreamer.c
  group lvgl/src/libs/libjpeg_turbo
    ../lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group lvgl/src/libs/libpng
    ../lvgl/src/libs/libpng/: lv_libpng.c
  group lvgl/src/libs/libwebp
    ../lvgl/src/libs/libwebp/: lv_libwebp.c
  group lvgl/src/libs/lodepng
    ../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group lvgl/src/libs/lz4
    ../lvgl/src/libs/lz4/: lz4.c
  group lvgl/src/libs/nanovg
    ../lvgl/src/libs/nanovg/: nanovg.c
  group lvgl/src/libs/qrcode
    ../lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group lvgl/src/libs/rle
    ../lvgl/src/libs/rle/: lv_rle.c
  group lvgl/src/libs/rlottie
    ../lvgl/src/libs/rlottie/: lv_rlottie.c
  group lvgl/src/libs/svg
    ../lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
  group lvgl/src/libs/thorvg
    ../lvgl/src/libs/thorvg/: tvgAccessor.cpp tvgAnimation.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgGlCanvas.cpp tvgInitializer.cpp tvgLoader.cpp tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieExpressions.cpp tvgLottieInterpolator.cpp tvgLottieLoader.cpp tvgLottieModel.cpp tvgLottieModifier.cpp tvgLottieParser.cpp tvgLottieParserHandler.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgText.cpp tvgWgCanvas.cpp tvgXmlParser.cpp
  group lvgl/src/libs/tiny_ttf
    ../lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group lvgl/src/libs/tjpgd
    ../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal
    ../lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
  group lvgl/src/libs/vg_lite_driver/VGLite
    ../lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
  group lvgl/src/libs/vg_lite_driver/VGLiteKernel
    ../lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group lvgl/src
    ../lvgl/src/: lv_init.c
  group lvgl/src/misc/cache/class
    ../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group lvgl/src/misc/cache/instance
    ../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group lvgl/src/misc/cache
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group lvgl/src/misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group lvgl/src/osal
    ../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group lvgl/src/others/file_explorer
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c
  group lvgl/src/others/fragment
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group lvgl/src/others/translation
    ../lvgl/src/others/translation/: lv_translation.c
  group lvgl/src/stdlib/builtin
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group lvgl/src/stdlib/clib
    ../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/stdlib
    ../lvgl/src/stdlib/: lv_mem.c
  group lvgl/src/stdlib/micropython
    ../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group lvgl/src/stdlib/rtthread
    ../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgl/src/stdlib/uefi
    ../lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group lvgl/src/themes/default
    ../lvgl/src/themes/default/: lv_theme_default.c
  group lvgl/src/themes
    ../lvgl/src/themes/: lv_theme.c
  group lvgl/src/themes/mono
    ../lvgl/src/themes/mono/: lv_theme_mono.c
  group lvgl/src/themes/simple
    ../lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgl/src/tick
    ../lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets/3dtexture
    ../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group lvgl/src/widgets/animimage
    ../lvgl/src/widgets/animimage/: lv_animimage.c
  group lvgl/src/widgets/arc
    ../lvgl/src/widgets/arc/: lv_arc.c
  group lvgl/src/widgets/arclabel
    ../lvgl/src/widgets/arclabel/: lv_arclabel.c
  group lvgl/src/widgets/bar
    ../lvgl/src/widgets/bar/: lv_bar.c
  group lvgl/src/widgets/button
    ../lvgl/src/widgets/button/: lv_button.c
  group lvgl/src/widgets/buttonmatrix
    ../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group lvgl/src/widgets/calendar
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group lvgl/src/widgets/canvas
    ../lvgl/src/widgets/canvas/: lv_canvas.c
  group lvgl/src/widgets/chart
    ../lvgl/src/widgets/chart/: lv_chart.c
  group lvgl/src/widgets/checkbox
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
  group lvgl/src/widgets/dropdown
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
  group lvgl/src/widgets/gif
    ../lvgl/src/widgets/gif/: lv_gif.c
  group lvgl/src/widgets/image
    ../lvgl/src/widgets/image/: lv_image.c
  group lvgl/src/widgets/imagebutton
    ../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group lvgl/src/widgets/ime
    ../lvgl/src/widgets/ime/: lv_ime_pinyin.c
  group lvgl/src/widgets/keyboard
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
  group lvgl/src/widgets/label
    ../lvgl/src/widgets/label/: lv_label.c
  group lvgl/src/widgets/led
    ../lvgl/src/widgets/led/: lv_led.c
  group lvgl/src/widgets/line
    ../lvgl/src/widgets/line/: lv_line.c
  group lvgl/src/widgets/list
    ../lvgl/src/widgets/list/: lv_list.c
  group lvgl/src/widgets/lottie
    ../lvgl/src/widgets/lottie/: lv_lottie.c
  group lvgl/src/widgets/menu
    ../lvgl/src/widgets/menu/: lv_menu.c
  group lvgl/src/widgets/msgbox
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
  group lvgl/src/widgets/objx_templ
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group lvgl/src/widgets/property
    ../lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
  group lvgl/src/widgets/roller
    ../lvgl/src/widgets/roller/: lv_roller.c
  group lvgl/src/widgets/scale
    ../lvgl/src/widgets/scale/: lv_scale.c
  group lvgl/src/widgets/slider
    ../lvgl/src/widgets/slider/: lv_slider.c
  group lvgl/src/widgets/span
    ../lvgl/src/widgets/span/: lv_span.c
  group lvgl/src/widgets/spinbox
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
  group lvgl/src/widgets/spinner
    ../lvgl/src/widgets/spinner/: lv_spinner.c
  group lvgl/src/widgets/switch
    ../lvgl/src/widgets/switch/: lv_switch.c
  group lvgl/src/widgets/table
    ../lvgl/src/widgets/table/: lv_table.c
  group lvgl/src/widgets/tabview
    ../lvgl/src/widgets/tabview/: lv_tabview.c
  group lvgl/src/widgets/textarea
    ../lvgl/src/widgets/textarea/: lv_textarea.c
  group lvgl/src/widgets/tileview
    ../lvgl/src/widgets/tileview/: lv_tileview.c
  group lvgl/src/widgets/win
    ../lvgl/src/widgets/win/: lv_win.c
  group lvgl
    ../lvgl/: lv_conf.h lv_port_indev.h lv_port_lcd_stm32.h lv_version.h lvgl.h lvgl_private.h
  group interface
    ./interface/: XPT2046.c XPT2046.h
  group ui
    ./ui/: noto_sans_sc_16.c user_home.c user_home.h card_render.c doudizhu_adapter.c doudizhu_font.c game_anim.c game_logic.c game_ui.c graphics_data.c suit_image.c touch_handler.c
software components: CMSIS:CORE 4.3.0
